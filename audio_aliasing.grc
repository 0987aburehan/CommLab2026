options:
  parameters:
    generate_options: qt_gui
    id: audio_aliasing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: D
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '6'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/D)
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: int(samp_rate/D)
    type: float
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Audio sample taken from:
      http://www0.cs.ucl.ac.uk/teaching/GZ05/samples/
    file: /media/sf_ECLR16_-_Communication_Engineering_Laboratory/Exp 1/N3/tone.wav
    repeat: 'True'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: D
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate/D
    fc: '0'
    fftsize: '1024'
    type: float
    update_time: '0.00001'
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_wavfile_source_0_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', audio_sink_0, '0']
- [mmse_resampler_xx_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
